# Keil uVision project PY32_Test_ADC_UART.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: PY32F003x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32_Test_ADC_UART
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: PY32F003x6
  c include: .\Objects;..\PY32F0xx_Firmware-master\PY32F0xx_Firmware-master\Drivers\PY32F0xx_HAL_Driver\Src;..\PY32F0xx_Firmware-master\PY32F0xx_Firmware-master\Drivers\PY32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./Objects/: main.c main.h py32f0xx_hal_conf.h py32f0xx_hal_msp.c py32f0xx_it.c py32f0xx_it.h
  group HAL_SRC
    ../PY32F0xx_Firmware-master/PY32F0xx_Firmware-master/Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
